# Keil uVision project EVBKS5.uvprojx, settings and files
target EVBKS5 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EVBKS5 +hex
  BeforeMake: ..\..\Script\EVBKS5_Convert.bat
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,STM32_PLATFORM,EVBKS5
  c include: ..\..\App\common\inc;..\..\App\algo\inc;..\..\Config;..\..\Middleware\common\inc;..\..\Middleware\common\src;..\..\Middleware\platform\stm32\inc;..\..\Driver\stm32f4xx\cmsis\inc;..\..\Driver\stm32f4xx\peripheral\inc;..\..\Driver\stm32f4xx\peripheral\inc\Legacy;..\..\Middleware\freertos\CMSIS_RTOS;..\..\Middleware\freertos\include;..\..\Middleware\freertos\portable\RVDS\ARM_CM4F;..\..\Middleware\usb\device\Class\CDC\Inc;..\..\Middleware\usb\device\Core\Inc;..\..\App\algo\inc;..\..\..\DSP\Include\dsp;..\..\..\DSP\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../../App/common/src/: cmdprocess.c config.c dataprocess.c main.c utilities.c system.c
    ../../App/algo/lib/: BodySensing.lib
  group Middleware/common
    ../../Middleware/common/src/: banyan.c platform.c
  group Middleware/platform
    ../../Middleware/platform/stm32/src/: stm32_clock.c stm32_flash.c stm32_gpio.c stm32_hal_msp.c stm32_hal_timebase_tim.c stm32_i2c.c stm32_it.c stm32_spi.c stm32_uart.c stm32_misc.c
  group Middleware/usb
    ../../Middleware/usb/device/Class/CDC/Src/: usbd_cdc.c usbd_cdc_if.c
    ../../Middleware/usb/device/Core/Src/: usb_device.c usbd_conf.c usbd_core.c usbd_ctlreq.c usbd_desc.c usbd_ioreq.c
  group Driver
    ../../Driver/stm32f4xx/cmsis/src/: system_stm32f4xx.c startup_stm32f429xx.s
    ../../Driver/stm32f4xx/peripheral/src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group DSP
    ../../../DSP/Source/TransformFunctions/: arm_cfft_f32.c arm_bitreversal.c arm_bitreversal2.c arm_cfft_radix8_f32.c arm_cfft_init_f32.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c
    ../../../DSP/Source/SupportFunctions/: arm_copy_f32.c
    ../../../DSP/Source/BasicMathFunctions/: arm_mult_f32.c
    ../../../DSP/Source/ComplexMathFunctions/: arm_cmplx_mag_f32.c
    ../../../DSP/Source/CommonTables/: arm_const_structs.c arm_common_tables.c
software components: CMSIS:CORE 5.5.0
