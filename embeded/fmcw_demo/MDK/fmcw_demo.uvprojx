# Keil uVision project fmcw_demo.uvprojx, settings and files
target flashcode (6160000::V6.16::ARMCLANG)
  device: STM32F429VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: flashcode +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_USB_OTG_HS,USE_ULPI_PHY,HSE_VALUE=8000000,STM32F429_439xx,USE_STDPERIPH_DRIVER, __DEBUG,USE_DEVICE_DRIVER_LIB,_CC_ARM,DEBUG_MODE,ARM_MATH_CM4,SUPPORT_MCU_FIRM_UPDATE,__TARGET_FPU_VFP,__FPU_PRESENT,__FPU_USED,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\MDK;..\driver\inc;..\driver\src;..\dsp\Include;..\common\inc;..\HAL\inc;..\HAL\flash;..\HAL\mcu_sdk;..\HAL\rtt;..\USB\STM32_USB_OTG_Driver\inc;..\USB\STM32_USB_Device_Library\Core\inc;..\USB\STM32_USB_Device_Library\Class\cdc\inc;..\USB\VCP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group common
    ../common/src/: memalloc.c ringbuffer.c stm32f4xx_it.c system_stm32f4xx.c
    ../common/inc/: sys.h
  group source
    ../common/: startup_stm32f429_439xx.s
    ../: main.c
  group driver
    ../driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group dsp
    ../dsp/Source/StatisticsFunctions/: arm_max_f32.c arm_min_f32.c arm_mean_q15.c arm_std_f32.c arm_rms_f32.c arm_mean_f32.c arm_var_f32.c
    ../dsp/Source/MatrixFunctions/: arm_mat_init_f32.c arm_mat_mult_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c
    ../dsp/Source/FilteringFunctions/: arm_fir_decimate_init_q15.c arm_fir_decimate_q15.c
    ../dsp/Source/TransformFunctions/: arm_cfft_radix2_f32.c arm_cfft_radix2_init_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c arm_cfft_init_f32.c arm_cfft_f32.c arm_bitreversal.c arm_bitreversal2.S arm_cfft_radix8_f32.c
    ../dsp/Source/BasicMathFunctions/: arm_offset_q15.c
    ../dsp/Source/ComplexMathFunctions/: arm_cmplx_mult_cmplx_f32.c arm_cmplx_mag_f32.c
    ../dsp/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../dsp/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
  group hal
    ../HAL/src/: mcu429_hal.c uart_hal.c radar_hal.c usb_hs_hal.c fpga_hal.c sysclk.c usart.c
  group communication
    ../HAL/mcu_sdk/: mcu_api.c mcu_ota_handler.c protocol.c system.c
  group debug
    ../HAL/rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group USB_device
    ../USB/VCP/: usbd_usr.c usbd_cdc_vcp.c usb_bsp.c usbd_desc.c
    ../USB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
    ../USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
software components: CMSIS:CORE 5.5.0
